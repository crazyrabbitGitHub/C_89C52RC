# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lcd1602;.\delay
  group main
    ./: STARTUP.A51 main.c
  group lcd1602
    ./lcd1602/: LCD1602.c
  group delay
    ./delay/: Delay.c
  group matrix_key
    ./: MatrixKey.c MatrixKey.h
  group utils
    ./: MathUtils.c MathUtils.h
