# Keil uVision project project.uvproj, settings and files
target progress (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\lcd1602;.\math;.\matrixKey
  group main
    ./: main.c
  group delay
    ./delay/: Delay.c
  group lcd1602
    ./lcd1602/: LCD1602.c
  group matrixKey
    ./matrixKey/: MatrixKey.c MatrixKey.h
  group util
    ./math/: MathUtils.c
  group timer
    ./timer/: Timer.c
    $TC_ROOT$/../../../projects/C_89C52RC/6-定时器/timer/: Timer.h
