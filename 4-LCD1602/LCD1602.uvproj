# Keil uVision project LCD1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c
  group LCD1602
    ./: LCD1602.h LCD1602.c
  group Delay
    ./: Delay.c Delay.h
